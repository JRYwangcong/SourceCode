# Keil uVision project AOC_ID2008_14Lan_256KFlash.uvproj, settings and files
target ==========AOC37Series========== (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_2237Fw-TSUMU58EHL_1-AUOM215HW01V7-090630-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_2237Fw
  group Source
    ./: Common.c isr.c ms_rwreg.c L51_4BANK.A51 STARTUP.A51 CompFont.LIB CompProp_5Set.LIB DDC2Bi_Isr.c
  group bank0
    ./: main.c Gamma.c GammaLd.LIB MenuStr.c msOSD.c menu.c
  group bank1
    ./: AutoFunc.c Adjust.c NVRam.c Ms_PM.c MsDLC.c detect.c MsHDCP.c msHDMI.c mStar.c mode.c ACE.LIB msHDMIACE.c MenuFunc.c MainTitleFont_1.c MsADC.c MsID_V2.LIB MsOVD_LIB_V03.LIB
  group bank2
    ./: DDC.c Global.c msDAC.c MainTitleFont.c mcu.c power.c misc.c PropFont.c
  group bank3
    ./: UserPref.c Keypad.c SynaOT.c UserOT.c ScanKey.c i2c.c Debug.c DDC2Bi.c msflash.c UserDataSpace.C
  group last_file
    ./: MST_INIT_2011.A51
target AOC_e937Fw (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e937Fw-TSUMU1PLL-M185XW01-100128-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e937Fw
target AOC_2037F_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_2037F-TSUMU58NHL-CMOM20001L02-100204-V006"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_2037F,TSUMXXNX=1
target AOC_e2037F_TPM_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e2037F-TSUMU58NHL-TPM20001L02-100204-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e2037F,TSUMXXNX=1,PanelType=PanelTPM200O1L02
target AOC_e2037F_LG_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e2037F-TSUMU58NHL-LM200WD3TLA1-100326-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e2037F,PanelType=PanelLM200WD3TLA1
target AOC_2237Fw_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_2237Fw-TSUMU58NHL_1-AUOM215HW01V7-V007"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_2237Fw,TSUMXXNX=1
target AOC_e2237Fw_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e2237Fw-TSUMU58NHL_1-AUOM215HW01V6-V004"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e2237Fw,TSUMXXNX=1,PanelType=PanelAUOM215HW01V6
target AOC_e2237Fw_VB_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC-e2237Fw-TSUMU58NWHL5-M215HW01VB-101021-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e2237Fw,TSUMXXNX=1,PanelType=PanelAUOM215HW01VB
target AOC_E2237Fwh (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC-E2237Fwh-TSUMU88MWDT3-AUOM215HW01V6-V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2237Fwh
target AOC_e2237Fw2_TSUMXXQX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC-E2237Fw2-TSUMO88QW-M215HW01V6-20100819-V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e2237Fw2,PanelType=PanelAUOM215HW01V6
target AOC_e2237Fw2_VB_TSUMXXQX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC-E2237Fw2-TSUMO88QW-M215HW01VB-20101021-V004"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e2237Fw2,PanelType=PanelAUOM215HW01VB
target AOC_e2437Fw_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e2437Fw-TSUMU58NHL-TPM236H3L0A-091222-V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e2437Fw,TSUMXXNX=1
target AOC_e2437F_V6_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e2437F-TSUMU58NHL-AUOM240HW01V6-100421-V004"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e2437F,TSUMXXNX=1,PanelType=PanelAUOM240HW01V6
target AOC_e2437F_VB_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e2437F-TSUMU58NHL-AUOM240HW01VB-100921-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e2437F,TSUMXXNX=1,PanelType=PanelAUOM240HW01VB
target AOC_2437F_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_2437F-TSUMU58NHL-AUOM240HW01V7-100421-V004"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_2437F,TSUMXXNX=1
target AOC_E2437Fh (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC-E2437Fh-TSUMU88MWDT3-M240HW01VB-100917-V007"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2437Fh
target AOC_e2437F2_TSUMXXQX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC-E2437F2-TSUMO88QW-M240HW01VB-20101021-V004"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e2437F2
target ============2330V============ (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: as above
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_2237Fw
target AOC_2330V+ (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_2330V+-TSUMU58EHL-LM230WF1-100122-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_2330V_PLUS
target AOC_2330V_14L_LTM (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_2330V_14L-TSUMU58EHL-LTM230HT01-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_2330V_14L,PanelType=PanelLTM230HT01
target AOC_2330V_14L_LG (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_2330V_14L-TSUMU58EHL-LM230WF1TLA3-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_2330V_14L,PanelType=PanelLM230WF1TLA3
target ----------------------------- (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e937Fw-TSUMU1PLL-M185XW01-100128-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e937Fw
target AOC_1620Swa (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_1620Swa-TSUM1PLR-AUOM156XW01-100121-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_1620Swa
target AOC_e1620Swb (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e1620Swb-TSUM18PWR-PanelCLAA156WB11A-110318-V004"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e1620Swb
target AOC_e1620Swb_1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e1620Swb-TSUM18PWR-PanelCMON156B6L0B-V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e1620Swb_1,PanelType=PanelCMON156B6L0B
target AOC_e1620Swb_BOE (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e1620Swb-TSUM18PWR-PanelBOEHT156WXB-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e1620Swb_1,PanelType=PanelBOEHT156WXB
target AOC_e1621Swb_ (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e1621Swb-TSUM18PWR-PanelCLAA156WB11A-110322-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e1621Swb_
target AOC_2219P2_3329 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_2219P2_3329-TSUMO58GHL-LTM220M1L01-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_2219P2_3329
target ENVISION_G2470_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION-G2470-TSUMU58NHL-AUOM240HW01V7-V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_G2470
target AOC_e1621Swb (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC-e1621Swb-TSUM1PNWR-AUOB156XW02V6-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e1621Swb,TSUMXXNX=1
target ENVISION_P971l (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION-P971l-TSUM1PLR-TPM185B1XW01-100415-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P971l
target ENVISION_P2471_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION-P2471-TSUMU58NHL-AUOM240HW01V7-V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P2471,TSUMXXNX=1
target ENVISION_G2770_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION-G2770-TSUMU58NHL-AUOM270HW01V0-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_G2770
target ENVISION_P2071L_TPMC1D (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION-P2071L-TSUMU18NR-TPM200O1L02C1D-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P2071l,TSUMXXNX=1,PanelType=PanelTPM200O1L02C1D
target ENVISION_G2360g_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION-G2360g-TSUMU58NHL-LTM230HT01-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_G2360g
target AOC_919Vz (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_919Vz-TSUMO58QWHL-HSD190MEN4-100524-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_919Vz
target AOC_919Vz1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_919SZ-TSUMO58QWHL-PanelLM190E08-111026-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_919Vz1
target AOC_919Sz (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_919Sz-TSUMO58QWHL-HSD190MEN4-100524-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_919Sz
target ENVISION_G2218 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION-G2218-TSUMU58N-LTM220M1L01-101009-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_G2218
target ENVISION_G2218_PLUS (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "G2218_PLUS-TSUMU58N-LTM220MT05-111031-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_G2218_PLUS
target AOC_931Fwa (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC-931Fwa-TSUMU18NWL5-TPM190A1-100927-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_931Fwa
target AOC_931Fwa_TMS190 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC-931Fwa_TMS190-TSUMU18NWL5-TMS190-110225-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_931Fwa_TMS190
target ENVISION_P2373wl (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISOIN_P2273wl-TSUMU58NHL-AUOM215HW01-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISOIN_P2273wl
target ENVISION_P2273wl_1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISOIN_P2273wl-TSUMU58PWHL-CLAA215FA04-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISOIN_P2273wl,PanelType=PanelCLAA215FA04
target ENVISION_P2473wl (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISOIN_P2473wl-TSUMU58NHL-PanelTPM236H3-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISOIN_P2473wl,PanelType=PanelTPM236H3L02
target ENVISION_G2460W (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_G2460W-TSUMU58P-PanelCMOM236H1L01-110314-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_G2460W,PanelType=PanelCMOM236H1L01_1
target ENVISION_G2460W_IVO (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_G2460W-TSUMU58P-PanelM236MWF1-110314-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_G2460W,PanelType=PanelM236MWF1
target ENVISION_G2770L (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_G2770L-TSUMU58NWHL-CMOM270HGEL10-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_G2770L
target AOC_e2795v (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e2795v-TSUMU58NWHL-CMOM270HGEL10-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e2795v
target AOC_1620Sw_TPM156B1L01 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e1620Sw-TSUMU18NWR5-PanelTPM156B1L01-110308-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_1620Sw_TPM156B1L01
target AOC_1620Sw_T (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e1620Sw-TSUMU18TR-TPM156B1WX-110421-V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_1620Sw_T,PanelType=PanelTPM156B1WX102TC
target AOC_2219P2_LTM220MT09 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_2219P2_TSUMO58QWHL_LTM220MT09-111207_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_2219P2_3834,PanelType=PanelLTM220MT09
target AOC_2219P2_TPM220Z1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_2219P2_TSUMO58QWHL_PanelTPM220Z1-111207_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_2219P2_3834,PanelType=PanelTPM220Z1
target ENVISOIN_P2273wlTPM (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISOIN_P2273wl-TSUMU58PWHL-TPM215HW01-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISOIN_P2273wlTPM
target =========TOUCH KEY========= (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISOIN_P2273wl-TSUMU58PWHL-M215HGEL10-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISOIN_P2273wl,PanelType=PanelCMOM215HGEL10
target ENVISION_P2271WS (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISOIN_P2271WS-TSUMU58PWHL-PanelAUOM215HW03-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISOIN_P2271WS,PanelType=PanelAUOM215HW01VC
target ENVISION_P971wal (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "P971wal-TSUMU18PWL-LTM185AT05-111108-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P971wal
target ENVISION_P2371l (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION-P2371-TSUMU58NHL-LM230WF5TLA1-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P2371l,TSUMXXNX=1
target ENVISION_P2371l2 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "P2371l2_TSUMU58N_PanelLM230WF5TLF1-120116_V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P2371l2
target ENVISION_P971waL2 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_P971waL2_TSUMU18PWL_PanelCMIM185BGEL22_20120202_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P971waL2
target ENVISION_H2276DL (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "H2276DL_TSUMU58PWHL_TPM220Z1-120308_V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_H2276DL
target AOC_E2795V_AUOM270HW01V2 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e2795v-TSUMU58PWHL-AUOM270-20120424-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2795V_AUOM270HW01V2
target AOC_e1620Swb_2 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e1620Swb-TSUMU18TR_LF_PanelLTN156AT24_P_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e1620Swb_2
target ENVISION_G2770L_L20 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_G2770L_TSUMU58PWHL_M270HGEL20_0502_V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_G2770L_L20
target ENVISOIN_P2473wl_L02 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENV_P2473wl-TSUMU58PWHL-M236HGEL20_120529-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISOIN_P2473wl_L02
target AOC_G2770L_AUOM270 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENV_G2770L_TSUMU58PWHL_AUOM270HW01_0502_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_G2770L_AUOM270
target ENV_P971WALS_TPM185 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENV_P971WALS_TSUMU18PWL_TPM185B1_120726_V004"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENV_P971WALS_TPM185
target ENVISOIN_P2473wl_TPM236 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENV_P2473wl-TSUMU58PWHL-TPM236WU_120718-V002"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISOIN_P2473wl_TPM236
target ENV_P971WLS_TPM185_NO_AUDIO (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENV_P971WLS_TSUMU18PWL_TPM185B1_N_A_120712_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENV_P971WLS_TPM185_NO_AUDIO
target AOC_E2795V_L20 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_E2795V_TSUMU58PWHL_M270HGEL20_0810_V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_E2795V_L20
target ENVISION_H2473DL_AUO (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_H2473DL_AUOM240HW01VD_TSUMU58PWHL_V001_20121101"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_H2473DL,PanelType=PanelAUOM240HW01VD
target ENVISION_H2473DL_TPM (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_H2473DL_TPM240WF1_HTN01_TSUMU58PWHL_V001_20130327"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_H2473DL,PanelType=PanelTPM240WF1_HTN01
target ENVISION_H2473DL_TPMHW01 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENV_H2473DL_TPM240WF1_TSUMU58PWHL_V003_20130719"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_H2083WM
