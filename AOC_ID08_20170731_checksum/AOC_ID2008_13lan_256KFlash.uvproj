# Keil uVision project AOC_ID2008_13lan_256KFlash.uvproj, settings and files
target DEBUG MODE (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat AOC
  c flags: Optimize=9
  c define: DEBUG_EN
  group Source
    ./: main.c Common.c isr.c ms_rwreg.c L51_4BANK.A51 CompFont.LIB STARTUP.A51 DDC2Bi_Isr.c
  group bank0
    ./: MenuStr.c msOSD.c menu.c
  group bank1
    ./: NVRam.c Global.c MenuFunc.c i2c.c DDC.c mode.c mStar.c UserPref.c detect.c AutoFunc.c MsHDCP.c MsDLC.c msHDMI.c msHDMIACE.c MsOVD_W3.LIB misc.c ACE.LIB DDC2Bi.c MSTRTE.LIB GammaLd.LIB Debug.c Gamma.c power.c msDAC.c Adjust.c Ms_PM.c MsID_V1.LIB
  group bank2
    ./: mcu.c MainTitleFont.c CompProp.LIB PropFont.c Keypad.c CompProp_3Set.LIB
  group bank3
    ./: msflash.c UserOT.c ScanKey.c SynaOT.c UserDataSpace.C
  group last_file
    ./: MST_INIT_2011.A51
target ENVISION_P2071l_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION-P2071l-TSUMU18NR-TPM200O1-091209-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P2071l,TSUMXXNX=1
target ENVISION_P2271w_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_P2271w-TSUMU58NHL-AUOM215HW01V7-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P2271w,TSUMXXNX=1
target ENVISION_P2471w (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_P2471w-TSUMU58MDT3_1-CMOM236H1L07-090701-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P2471w
target ENVISION_P2471w_TSUMXXNX (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_P2471w-TSUMU58NHL_1-CMOM236H1L07-090701-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P2471w,TSUMXXNX=1
target ENVISION_P971wl (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_P971wl-TSUM1PLR-TPM185B1L01-091221-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P971wl
