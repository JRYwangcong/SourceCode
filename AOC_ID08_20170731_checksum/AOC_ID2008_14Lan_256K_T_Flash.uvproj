# Keil uVision project AOC_ID2008_14Lan_256K_T_Flash.uvproj, settings and files
target ==========T serise============ (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e1620Swb-TSUM18PWR-PanelCMON156B6L0B-V001"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e1620Swb_1,PanelType=PanelCMON156B6L0B
  group Source
    ./: Common.c isr.c ms_rwreg.c L51_4BANK.A51 STARTUP.A51 CompFont.LIB CompProp_5Set.LIB DDC2Bi_Isr.c
  group bank0
    ./: main.c Gamma.c GammaLd.LIB MenuStr.c msOSD.c menu.c
  group bank1
    ./: AutoFunc.c Adjust.c NVRam.c Ms_PM.c MsDLC.c detect.c MsHDCP.c msHDMI.c mStar.c mode.c msHDMIACE.c MenuFunc.c MainTitleFont_1.c MsADC.c MsID_V2.LIB MsOVD_LIB_V03.LIB ACE_TSUMT.LIB ITE6251.c
  group bank2
    ./: DDC.c Global.c msDAC.c MainTitleFont.c mcu.c power.c misc.c PropFont.c msMiniLVDSI2C.c
  group bank3
    ./: UserPref.c Keypad.c SynaOT.c UserOT.c ScanKey.c i2c.c Debug.c DDC2Bi.c msflash.c UserDataSpace.C
  group last_file
    ./: MST_INIT_2011.A51
target AOC_1620Sw_T (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e1620Sw-TSUMU18TR-TPM156B1WX-110421-V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_1620Sw_T,PanelType=PanelTPM156B1WX102TC
target ENVISION_P2071L_T (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION-P2071L-TSUMU18TR-LTM200KT10-110718-V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P2071L_T,PanelType=PanelLTM200KT01
target AOC_e1620Swb_2 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e1620Swb_TSUMU18TR_LTN156AT24_20120530_V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e1620Swb_2,PanelType=PanelLTN156AT24_P
target AOC_e1620Swb_3 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e1620Swb_TSUMU18TR_HB156WX1_20120611_V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e1620Swb_2,PanelType=PanelHB156WX1_100
target AOC_e1620Swb_4 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "AOC_e1620Swb_TSUMU18TR_B156XTN02_20120710_V003"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=AOC_e1620Swb_2,PanelType=PanelB156XTN02
target ENVISION_H2030WS (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_H2030WS_PanelTPM195WD1_FGEL03_TSUMU19BR9_V004_20140826"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_H2030WS
target ENVISION_H2083WL (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_H2083WL_CMIM195FEG_TSUMU18TR_V001_20121030"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_H2083WL
target ENVISION_H2083LS (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_H2083LS_LNTBM200WD3_TSUMU18TR_V001_20121030"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_H2083LS
target ENVISION_P971waL_CMI (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_P971waL_CMIM185BGEL22_TSUMU18TR_V001_20130102_"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P971waL_CMI
target ENVISION_P971WALS (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_P971WALS_PanelTPM185B1_WX3400_TSUMU18TR_V001_20130102_"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_P971WALS
target ENVISION_H2083WM (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: 256KMerge.bat "ENVISION_H2083WM_PanelM200HJJL20_TSUMU19BR9_V001_20150417"
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_H2083WM
target ENVISION_JRY1PTRL (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: Merge256K.bat TSUM AOC_256K
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_JRY1PTRL
target ENVISION_JRYL1PTR_EV1 (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: Merge256K.bat TSUM AOC_256K
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_JRYL1PTR_EV1
target ------SL-BOARD------------- (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: Merge256K.bat TSUM AOC_256K
  c flags: Optimize=8 SizeSpeed=1
target ENVISION_R2218WS (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: Merge256K.bat TSUM AOC_256K
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_R2218WS
target ENVISION_R2018WS (MCS-51)
  device: MTV412M Myson Technology
  cpu: IRAM(0-0xFF) XRAM(0xFF-0x3FF) IROM(0-0xFFFF) CLOCK(12000000)
  output: TSUM +hex
  AfterMake: Merge256K.bat TSUM AOC_256K
  c flags: Optimize=8 SizeSpeed=1
  c define: ModelName=ENVISION_R2018WS
