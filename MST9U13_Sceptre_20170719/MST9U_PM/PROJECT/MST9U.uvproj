# Keil uVision project MST9U.uvproj, settings and files
target MST9U_PM (MCS-51)
  device: 8xC51RD+ Philips
  cpu: IRAM(0 - 0xFF) IROM(0-0xFFFF) XRAM(0 - 0x2FF) CLOCK(33000000) MODP2
  output: TSUM +hex
  AfterMake: 64KMerge.bat PM.bin
  c flags: Optimize=9 SizeSpeed=1
  c define: ModelName = MST9U_DEMO, CHIP_ID = MST9U
  c include: ..\Code\INC;..\Code\DRIVER\MST9U\INC;..\Code\DRIVER\MST9U3\INC;..\Code\DRIVER\INC
  group source
    ../Code/: Common.c isr.c ms_rwreg.c NVRam.c hwi2c.c I2c.c swi2c_debug.c msAPI_DaisyChain.c
    ./: STARTUP.A51 L51_MST.A51
    ../Code/INC/: types.h
  group Bank0
    ../Code/: Global.c Keypad.c main.c mcu.c Debug.c misc.c mdrv_mhl.c mhal_mhl.c drvmStar.c drvADC.c halMBX.c halMBXINT.c drvMBX.c drvMBXMsgPool.c msAPI_MailBox.c drvGPIO.c Buzzer.c mapi_mhl.c mapi_tmds.c mapi_combo.c MsIR.c IrFunc.c
    ../Code/DRIVER/: drvPM.c
target MST9U2_PM (MCS-51)
  device: 8xC51RD+ Philips
  cpu: as above
  output: TSUM +hex
  AfterMake: 64KMerge.bat PM.bin
  c flags: Optimize=9 SizeSpeed=1
  c define: ModelName = MST9U_DEMO, CHIP_ID = MST9U2
  c include: ..\Code\INC;..\Code\DRIVER\INC;..\Code\DRIVER\MST9U\INC;..\Code\DRIVER\MST9U3\INC
target MST9U3_PM (MCS-51)
  device: 8xC51RD+ Philips
  cpu: as above
  output: TSUM +hex
  AfterMake: 64KMerge.bat PM.bin
  c flags: Optimize=9 SizeSpeed=1
  c define: ModelName = MST9U3_DEMO, CHIP_ID = MST9U3
  c include: as above
target MST9U_PM_64Bit (MCS-51)
  device: 8xC51RD+ Philips
  cpu: as above
  output: TSUM +hex
  AfterMake: 64KMerge_64Bit.bat TSUM PM.bin
  c flags: Optimize=9 SizeSpeed=1
  c define: ModelName = MST9U_DEMO, CHIP_ID = MST9U
  c include: as above
target MST9U2_PM_64Bit (MCS-51)
  device: 8xC51RD+ Philips
  cpu: as above
  output: TSUM +hex
  AfterMake: 64KMerge_64Bit.bat TSUM PM.bin
  c flags: Optimize=9 SizeSpeed=1
  c define: ModelName = MST9U_DEMO, CHIP_ID = MST9U2
  c include: as above
target MST9U3_PM_64Bit (MCS-51)
  device: 8xC51RD+ Philips
  cpu: as above
  output: TSUM +hex
  AfterMake: 64KMerge_64Bit.bat TSUM PM.bin
  c flags: Optimize=9 SizeSpeed=1
  c define: ModelName = MST9U3_DEMO, CHIP_ID = MST9U3
  c include: as above
